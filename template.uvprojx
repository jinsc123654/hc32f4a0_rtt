# Keil uVision project template.uvprojx, settings and files
target rt-thread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HC32F4A0RITB HDSC
  pack: HDSC.HC32F4A0.1.0.8
  cpu: IRAM(0x1FFE0000,0x80000) IROM(0x00000000,0x200000) IROM2(0x03000000,0x1800) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, USE_STDPERIPH_DRIVER, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, USE_DDL_DRIVER, HC32F4A0, __RTTHREAD__, LFS_CONFIG=lfs_config.h, __DEBUG
  c include: rt-thread\components\drivers\include;rt-thread\components\drivers\include;applications\components\DAPLink\Source\target;libraries\hc32f4a0_ddl\drivers\hc32_ll_driver\inc;rt-thread\components\libc\compilers\common\include;libraries\hc32_drivers;applications\flmparse;applications\offline_download;rt-thread\components\libc\posix\io\epoll;board;rt-thread\components\drivers\include;rt-thread\components\libc\posix\ipc;packages\littlefs-latest;applications\components\DAPLink\Source\hic_hal;applications\components\CherryRB;packages\CherryUSB-1.3.0\class\cdc;rt-thread\components\finsh;rt-thread\components\dfs\dfs_v1\filesystems\devfs;rt-thread\components\drivers\include;rt-thread\components\legacy\dfs;board\config\usb_config;.;rt-thread\components\drivers\include;applications\components\DAPLink\Source;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\legacy;packages\CherryUSB-1.3.0\osal;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\cortex-m4;packages\CherryUSB-1.3.0\class\vendor\serial;rt-thread\components\dfs\dfs_v1\include;packages\CherryUSB-1.3.0\class\dfu;packages\SEGGER_RTT-latest;rt-thread\components\libc\posix\io\poll;rt-thread\components\libc\compilers\common\extension\fcntl\octal;packages\CherryUSB-1.3.0\class\wireless;packages\SEGGER_RTT-latest\RTT;board\ports;board\config;rt-thread\components\drivers\spi\sfud\inc;rt-thread\components\drivers\spi;packages\CherryUSB-1.3.0\class\video;packages\CherryUSB-1.3.0\common;rt-thread\components\dfs\dfs_v1\filesystems\elmfat;packages\CherryUSB-1.3.0\class\midi;rt-thread\components\libc\posix\io\eventfd;board\ports\fal;packages\CherryUSB-1.3.0\class\msc;libraries\hc32f4a0_ddl\drivers\cmsis\Device\HDSC\hc32f4xx\Include;packages\CherryUSB-1.3.0\core;applications;packages\CherryUSB-1.3.0\class\vendor\net;rt-thread\components\utilities\ulog;applications\components\DAPLink\include;rt-thread\include;applications\components\DAPLink\Source\interface;rt-thread\components\libc\compilers\common\extension;rt-thread\components\drivers\include;rt-thread\components\drivers\include;libraries\hc32f4a0_ddl\drivers\cmsis\Include;rt-thread\components\fal\inc;libraries\hc32_drivers\drv_flash;packages\CherryUSB-1.3.0\class\hid;packages\CherryUSB-1.3.0\class\audio
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x3000000 size 0x1800
  memory RVCT9: RAM 0x1ffe0000 size 0x80000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: lcd.c power_control.c bsp_beep.c dap_main.c main.c usb2uart.c lcd_init.c dap_loop.c bsp_led.c usb_app.c xtal32_fcm.c dap_rtt.c
  group CherryUSB
    packages/CherryUSB-1.3.0/osal/: usb_osal_rtthread.c
    packages/CherryUSB-1.3.0/port/dwc2/: usb_dc_dwc2.c usb_glue_hc.c
    packages/CherryUSB-1.3.0/third_party/rt-thread-5.0/: usb_check.c usb_msh.c
    packages/CherryUSB-1.3.0/core/: usbd_core.c
    packages/CherryUSB-1.3.0/class/cdc/: usbd_cdc.c
    packages/CherryUSB-1.3.0/class/hid/: usbd_hid.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    rt-thread/components/drivers/core/: device.c
    rt-thread/components/drivers/ipc/: completion.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: adc.c
    rt-thread/components/drivers/mtd/: mtd_nor.c
    rt-thread/components/drivers/pin/: pin.c
    rt-thread/components/drivers/rtc/: rtc.c
    rt-thread/components/drivers/sdio/: block_dev.c gpt.c mmc.c mmcsd_core.c sd.c sdio.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c
  group Drivers
    board/: board.c board_config.c
    board/ports/: drv_spi_flash.c
    libraries/hc32f4a0_ddl/drivers/cmsis/Device/HDSC/hc32f4xx/Source/ARM/: startup_hc32f4a0.s
    libraries/hc32_drivers/: drv_adc.c drv_common.c drv_gpio.c drv_irq.c drv_rtc.c drv_sdio.c drv_spi.c drv_usart.c drv_usbd.c
    libraries/hc32_drivers/drv_flash/: drv_flash_f4.c
  group Fal
    rt-thread/components/fal/src/: fal.c fal_flash.c fal_rtt.c fal_partition.c
  group FAL
    board/ports/fal/: fal_flash_sfud_port.c
  group Filesystem
    rt-thread/components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    rt-thread/components/dfs/dfs_v1/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    rt-thread/components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group Kernel
    rt-thread/src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    rt-thread/src/klibc/: kstdio.c kstring.c
  group Legacy
    rt-thread/components/legacy/ipc/: workqueue_legacy.c
  group libcpu
    rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group Libraries
    libraries/hc32f4a0_ddl/drivers/hc32_ll_driver/src/: hc32_ll_clk.c hc32_ll_utility.c hc32_ll_efm.c hc32_ll_usb.c hc32f4a0_ll_interrupts_share.c hc32_ll_rmu.c hc32_ll_fcg.c hc32_ll_fcm.c hc32_ll_pwc.c hc32_ll_gpio.c hc32_ll_usart.c hc32_ll_tmr0.c hc32_ll_icg.c hc32_ll_interrupts.c hc32_ll_rtc.c hc32_ll_aos.c hc32_ll_adc.c hc32_ll_dma.c hc32_ll_sram.c hc32_ll_spi.c hc32_ll.c hc32_ll_sdioc.c
    libraries/hc32f4a0_ddl/drivers/cmsis/Device/HDSC/hc32f4xx/Source/: system_hc32f4a0.c
  group Libraries/CherryRB
    applications/components/CherryRB/: chry_ringbuffer.c
  group Libraries/DAPLINK
    applications/components/DAPLink/Source/: DAP_vendor.c SW_DP.c DAP.c SWO.c UART.c JTAG_DP.c
    applications/components/DAPLink/Source/interface/: swd_host.c SWD_flash.c
  group littlefs
    packages/littlefs-latest/: lfs_crc.c dfs_lfs.c lfs.c lfs_util.c
  group offline_download
    applications/flmparse/: flmparse.c
    applications/offline_download/: swd_download_file.c
  group Utilities
    rt-thread/components/utilities/ulog/: ulog.c
    rt-thread/components/utilities/ulog/backend/: console_be.c
