# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HC32F4A0RITB HDSC
  pack: HDSC.HC32F4A0.1.0.8
  cpu: IRAM(0x1FFE0000,0x80000) IROM(0x00000000,0x200000) IROM2(0x03000000,0x1800) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, USE_STDPERIPH_DRIVER, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, USE_DDL_DRIVER, HC32F4A0, __RTTHREAD__, LFS_CONFIG=lfs_config.h, __DEBUG
  c include: rt-thread\components\drivers\include;libraries\hc32f4a0_ddl\drivers\hc32_ll_driver\inc;rt-thread\components\libc\compilers\common\include;packages\lvgl-8.3.11\src\extra\themes\default;packages\lvgl-8.3.11\src\extra\libs\gif;rt-thread\components\libc\posix\io\eventfd;packages\lvgl-8.3.11\examples\layouts;packages\lvgl-8.3.11\src\extra\libs\sjpg;packages\lvgl-8.3.11\demos\keypad_encoder;applications\components\CherryRB;packages\CherryUSB-1.3.0\class\cdc;packages\lvgl-8.3.11\env_support\rt-thread;packages\lvgl-8.3.11\src;packages\lvgl-8.3.11\examples\layouts\grid;packages\lvgl-8.3.11\src\misc;packages\lvgl-8.3.11\src\extra\others\snapshot;packages\lvgl-8.3.11\src\extra\widgets\animimg;packages\lvgl-8.3.11\examples\libs;rt-thread\components\drivers\include;rt-thread\components\legacy;packages\CherryUSB-1.3.0\osal;rt-thread\components\libc\posix\io\epoll;packages\lvgl-8.3.11\examples\scroll;packages\lvgl-8.3.11\examples;board\ports;rt-thread\components\drivers\spi\sfud\inc;packages\lvgl-8.3.11\examples\others;packages\lvgl-8.3.11\src\extra\widgets\tabview;packages\CherryUSB-1.3.0\class\midi;packages\lvgl-8.3.11\src\extra\themes\basic;packages\lvgl-8.3.11\src\extra\others\gridnav;libraries\hc32f4a0_ddl\drivers\cmsis\Device\HDSC\hc32f4xx\Include;packages\CherryUSB-1.3.0\core;applications;packages\lvgl-8.3.11\src\draw\renesas;packages\lvgl-8.3.11\examples\libs\sjpg;rt-thread\components\fal\inc;packages\lvgl-8.3.11\src\extra\others;packages\lvgl-8.3.11\examples\libs\ffmpeg;packages\lvgl-8.3.11\src\extra\others\monkey;applications\components\DAPLink\Source\target;packages\lvgl-8.3.11\examples\libs\png;rt-thread\components\libc\compilers\common\extension\fcntl\octal;packages\lvgl-8.3.11\examples\anim;rt-thread\components\libc\posix\io\poll;applications\lvgl_porting;packages\lvgl-8.3.11\src\extra\widgets\calendar;rt-thread\components\drivers\include;packages\lvgl-8.3.11\examples\libs\rlottie;packages\lvgl-8.3.11\demos;.;packages\lvgl-8.3.11\demos\widgets;rt-thread\components\legacy\dfs;packages\lvgl-8.3.11\examples\others\snapshot;packages\lvgl-8.3.11\examples\others\fragment;applications\components\DAPLink\Source\hic_hal;packages\lvgl-8.3.11\src\extra\libs\freetype;packages\CherryUSB-1.3.0\class\hid;packages\lvgl-8.3.11\src\extra;packages\CherryUSB-1.3.0\class\msc;rt-thread\libcpu\arm\common;packages\lvgl-8.3.11\src\extra\themes;packages\SEGGER_RTT-latest\RTT;packages\lvgl-8.3.11\src\draw\arm2d;packages\lvgl-8.3.11\src\hal;packages\lvgl-8.3.11\src\extra\widgets\chart;packages\lvgl-8.3.11\examples\event;rt-thread\components\drivers\include;rt-thread\components\dfs\dfs_v1\filesystems\elmfat;packages\lvgl-8.3.11\src\extra\libs\qrcode;packages\lvgl-8.3.11\demos\music\assets;packages\lvgl-8.3.11\src\extra\widgets\spinbox;packages\lvgl-8.3.11\examples\others\imgfont;packages\lvgl-8.3.11\src\draw\nxp\vglite;packages\lvgl-8.3.11\examples\layouts\flex;packages\lvgl-8.3.11\src\extra\widgets\keyboard;packages\lvgl-8.3.11\src\extra\widgets\meter;packages\lvgl-8.3.11\examples\libs\freetype;packages\lvgl-8.3.11\src\extra\others\msg;packages\lvgl-8.3.11\src\extra\widgets;packages\CherryUSB-1.3.0\common;packages\lvgl-8.3.11\src\extra\layouts;board\ports\fal;packages\lvgl-8.3.11\src\draw\swm341_dma2d;libraries\hc32_drivers;packages\lvgl-8.3.11\src\extra\libs\bmp;board;rt-thread\components\drivers\include;rt-thread\components\libc\posix\ipc;packages\littlefs-latest;packages\lvgl-8.3.11\demos\benchmark;packages\SEGGER_RTT-latest;applications\offline_download;rt-thread\components\dfs\dfs_v1\filesystems\devfs;packages\lvgl-8.3.11\src\draw\stm32_dma2d;packages\lvgl-8.3.11\examples\widgets;packages\lvgl-8.3.11\examples\libs\bmp;packages\lvgl-8.3.11\demos\music;packages\lvgl-8.3.11\src\extra\layouts\grid;rt-thread\components\drivers\include;packages\lvgl-8.3.11\examples\libs\qrcode;libraries\hc32f4a0_ddl\drivers\cmsis\Include;rt-thread\libcpu\arm\cortex-m4;applications\components\DAPLink\Source\interface;rt-thread\components\dfs\dfs_v1\include;packages\lvgl-8.3.11\examples\styles;packages\lvgl-8.3.11\examples\others\monkey;packages\CherryUSB-1.3.0\class\wireless;packages\lvgl-8.3.11\src\extra\widgets\win;packages\lvgl-8.3.11\src\extra\others\ime;packages\lvgl-8.3.11\src\extra\libs\tiny_ttf;packages\CherryUSB-1.3.0\class\audio;packages\CherryUSB-1.3.0\class\video;packages\lvgl-8.3.11\examples\others\gridnav;packages\lvgl-8.3.11\src\extra\widgets\span;packages\CherryUSB-1.3.0\class\vendor\net;applications\components\DAPLink\include;rt-thread\include;packages\lvgl-8.3.11\src\draw\nxp\pxp;packages\lvgl-8.3.11\src\core;packages\lvgl-8.3.11\examples\get_started;packages\lvgl-8.3.11\src\extra\widgets\msgbox;applications\components\DAPLink\Source;packages\lvgl-8.3.11\demos\stress;rt-thread\components\drivers\include;packages\lvgl-8.3.11\examples\libs\gif;applications\flmparse;packages\lvgl-8.3.11\src\extra\libs\rlottie;rt-thread\components\finsh;rt-thread\components\drivers\include;packages\lvgl-8.3.11\src\extra\layouts\flex;packages\lvgl-8.3.11\src\draw\sw;packages\lvgl-8.3.11\examples\porting;packages\lvgl-8.3.11\src\extra\libs\png;board\config\usb_config;packages\lvgl-8.3.11\src\extra\themes\mono;packages\lvgl-8.3.11\src\extra\libs\ffmpeg;packages\lvgl-8.3.11\src\extra\libs\fsdrv;packages\CherryUSB-1.3.0\class\vendor\serial;packages\lvgl-8.3.11\src\extra\widgets\tileview;packages\CherryUSB-1.3.0\class\dfu;packages\lvgl-8.3.11\src\extra\widgets\spinner;packages\lvgl-8.3.11\src\extra\widgets\imgbtn;board\config;rt-thread\components\drivers\spi;packages\lvgl-8.3.11\src\extra\widgets\led;packages\lvgl-8.3.11\src\extra\widgets\menu;packages\lvgl-8.3.11\src\extra\widgets\colorwheel;packages\lvgl-8.3.11\examples\others\ime;packages\lvgl-8.3.11\src\draw\sdl;packages\lvgl-8.3.11\src\extra\others\fragment;packages\lvgl-8.3.11\src\draw;rt-thread\components\utilities\ulog;packages\lvgl-8.3.11\src\extra\widgets\list;rt-thread\components\libc\compilers\common\extension;packages\lvgl-8.3.11\src\widgets;rt-thread\components\drivers\include;packages\lvgl-8.3.11\src\extra\others\imgfont;packages\lvgl-8.3.11\examples\others\msg;libraries\hc32_drivers\drv_flash;packages\lvgl-8.3.11\src\extra\libs;packages\lvgl-8.3.11\src\font
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x3000000 size 0x1800
  memory RVCT9: RAM 0x1ffe0000 size 0x80000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: bsp_beep.c main.c usb_app.c dap_rtt.c lcd.c usb2uart.c lcd_init.c dap_main.c power_control.c bsp_led.c xtal32_fcm.c dap_loop.c
  group CherryUSB
    packages/CherryUSB-1.3.0/class/cdc/: usbd_cdc.c
    packages/CherryUSB-1.3.0/class/hid/: usbd_hid.c
    packages/CherryUSB-1.3.0/osal/: usb_osal_rtthread.c
    packages/CherryUSB-1.3.0/third_party/rt-thread-5.0/: usb_msh.c usb_check.c
    packages/CherryUSB-1.3.0/core/: usbd_core.c
    packages/CherryUSB-1.3.0/port/dwc2/: usb_dc_dwc2.c usb_glue_hc.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    rt-thread/components/drivers/core/: device.c
    rt-thread/components/drivers/ipc/: completion.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: adc.c dac.c
    rt-thread/components/drivers/mtd/: mtd_nor.c
    rt-thread/components/drivers/pin/: pin.c
    rt-thread/components/drivers/rtc/: rtc.c
    rt-thread/components/drivers/sdio/: block_dev.c gpt.c mmc.c mmcsd_core.c sd.c sdio.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c
  group Drivers
    board/: board.c board_config.c
    board/ports/: drv_spi_flash.c
    libraries/hc32f4a0_ddl/drivers/cmsis/Device/HDSC/hc32f4xx/Source/ARM/: startup_hc32f4a0.s
    libraries/hc32_drivers/: drv_adc.c drv_common.c drv_dac.c drv_gpio.c drv_irq.c drv_rtc.c drv_sdio.c drv_spi.c drv_usart.c drv_usbd.c
    libraries/hc32_drivers/drv_flash/: drv_flash_f4.c
  group Fal
    rt-thread/components/fal/src/: fal.c fal_partition.c fal_rtt.c fal_flash.c
  group FAL
    board/ports/fal/: fal_flash_sfud_port.c
  group Filesystem
    rt-thread/components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    rt-thread/components/dfs/dfs_v1/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    rt-thread/components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group Kernel
    rt-thread/src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    rt-thread/src/klibc/: kstdio.c kstring.c
  group Legacy
    rt-thread/components/legacy/ipc/: workqueue_legacy.c
  group libcpu
    rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group Libraries
    libraries/hc32f4a0_ddl/drivers/hc32_ll_driver/src/: hc32_ll_clk.c hc32_ll_utility.c hc32_ll_efm.c hc32_ll_usb.c hc32f4a0_ll_interrupts_share.c hc32_ll_rmu.c hc32_ll_fcg.c hc32_ll_fcm.c hc32_ll_pwc.c hc32_ll_gpio.c hc32_ll_usart.c hc32_ll_tmr0.c hc32_ll_icg.c hc32_ll_interrupts.c hc32_ll_rtc.c hc32_ll_aos.c hc32_ll_adc.c hc32_ll_dma.c hc32_ll_sram.c hc32_ll_spi.c hc32_ll.c hc32_ll_sdioc.c hc32_ll_dac.c
    libraries/hc32f4a0_ddl/drivers/cmsis/Device/HDSC/hc32f4xx/Source/: system_hc32f4a0.c
  group Libraries/CherryRB
    applications/components/CherryRB/: chry_ringbuffer.c
  group Libraries/DAPLINK
    applications/components/DAPLink/Source/: DAP_vendor.c SW_DP.c DAP.c SWO.c UART.c JTAG_DP.c
    applications/components/DAPLink/Source/interface/: swd_host.c SWD_flash.c
  group littlefs
    packages/littlefs-latest/: lfs.c lfs_crc.c lfs_util.c dfs_lfs.c
  group LVGL
    packages/lvgl-8.3.11/src/draw/renesas/: lv_gpu_d2_draw_label.c lv_gpu_d2_ra6m3.c
    packages/lvgl-8.3.11/examples/styles/: lv_example_style_11.c lv_example_style_6.c lv_example_style_15.c lv_example_style_3.c lv_example_style_4.c lv_example_style_7.c lv_example_style_10.c lv_example_style_5.c lv_example_style_13.c lv_example_style_9.c lv_example_style_14.c lv_example_style_2.c lv_example_style_12.c lv_example_style_8.c lv_example_style_1.c
    packages/lvgl-8.3.11/examples/widgets/textarea/: lv_example_textarea_2.c lv_example_textarea_1.c lv_example_textarea_3.c
    packages/lvgl-8.3.11/examples/widgets/calendar/: lv_example_calendar_1.c
    packages/lvgl-8.3.11/examples/widgets/span/: lv_example_span_1.c
    packages/lvgl-8.3.11/src/font/: lv_font_montserrat_24.c lv_font_montserrat_32.c lv_font_montserrat_40.c lv_font_montserrat_20.c lv_font_montserrat_26.c lv_font_montserrat_28_compressed.c lv_font_montserrat_46.c lv_font_unscii_16.c lv_font_montserrat_48.c lv_font_unscii_8.c lv_font.c lv_font_montserrat_12_subpx.c lv_font_montserrat_12.c lv_font_montserrat_28.c lv_font_montserrat_44.c lv_font_montserrat_10.c lv_font_montserrat_18.c lv_font_dejavu_16_persian_hebrew.c lv_font_montserrat_30.c lv_font_simsun_16_cjk.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_42.c lv_font_loader.c lv_font_montserrat_38.c lv_font_montserrat_14.c lv_font_montserrat_22.c lv_font_montserrat_8.c lv_font_fmt_txt.c lv_font_montserrat_16.c
    packages/lvgl-8.3.11/src/draw/: lv_draw_label.c lv_draw_line.c lv_img_cache.c lv_img_decoder.c lv_draw.c lv_draw_img.c lv_draw_transform.c lv_draw_mask.c lv_draw_rect.c lv_draw_layer.c lv_draw_arc.c lv_draw_triangle.c lv_img_buf.c
    packages/lvgl-8.3.11/src/extra/themes/mono/: lv_theme_mono.c
    packages/lvgl-8.3.11/src/misc/: lv_anim.c lv_gc.c lv_fs.c lv_area.c lv_lru.c lv_tlsf.c lv_bidi.c lv_timer.c lv_txt.c lv_log.c lv_style.c lv_txt_ap.c lv_utils.c lv_async.c lv_printf.c lv_anim_timeline.c lv_style_gen.c lv_color.c lv_mem.c lv_ll.c lv_math.c lv_templ.c
    packages/lvgl-8.3.11/src/draw/sw/: lv_draw_sw_layer.c lv_draw_sw_blend.c lv_draw_sw_img.c lv_draw_sw_transform.c lv_draw_sw_gradient.c lv_draw_sw_letter.c lv_draw_sw.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_arc.c lv_draw_sw_dither.c
    packages/lvgl-8.3.11/examples/event/: lv_example_event_1.c lv_example_event_2.c lv_example_event_3.c lv_example_event_4.c
    packages/lvgl-8.3.11/examples/assets/emoji/: img_emoji_F617.c
    packages/lvgl-8.3.11/examples/widgets/checkbox/: lv_example_checkbox_1.c lv_example_checkbox_2.c
    packages/lvgl-8.3.11/demos/music/assets/: img_lv_demo_music_slider_knob.c img_lv_demo_music_slider_knob_large.c img_lv_demo_music_icon_3_large.c img_lv_demo_music_btn_list_pause_large.c img_lv_demo_music_btn_list_play_large.c img_lv_demo_music_btn_play.c img_lv_demo_music_btn_rnd.c img_lv_demo_music_btn_rnd_large.c img_lv_demo_music_corner_right.c img_lv_demo_music_corner_right_large.c img_lv_demo_music_cover_1_large.c img_lv_demo_music_cover_3_large.c img_lv_demo_music_cover_3.c img_lv_demo_music_btn_play_large.c img_lv_demo_music_icon_1.c img_lv_demo_music_icon_1_large.c img_lv_demo_music_icon_2.c img_lv_demo_music_icon_2_large.c img_lv_demo_music_icon_3.c img_lv_demo_music_wave_bottom_large.c img_lv_demo_music_btn_loop_large.c img_lv_demo_music_btn_corner_large.c img_lv_demo_music_list_border_large.c img_lv_demo_music_corner_left.c img_lv_demo_music_btn_prev.c img_lv_demo_music_corner_left_large.c img_lv_demo_music_cover_2_large.c img_lv_demo_music_icon_4_large.c img_lv_demo_music_icon_4.c img_lv_demo_music_cover_1.c img_lv_demo_music_btn_list_pause.c img_lv_demo_music_btn_prev_large.c img_lv_demo_music_cover_2.c img_lv_demo_music_logo.c img_lv_demo_music_btn_list_play.c img_lv_demo_music_list_border.c img_lv_demo_music_btn_loop.c img_lv_demo_music_btn_next.c img_lv_demo_music_btn_next_large.c img_lv_demo_music_wave_top.c img_lv_demo_music_btn_pause.c img_lv_demo_music_wave_top_large.c img_lv_demo_music_btn_pause_large.c img_lv_demo_music_wave_bottom.c
    packages/lvgl-8.3.11/examples/widgets/obj/: lv_example_obj_2.c lv_example_obj_1.c
    packages/lvgl-8.3.11/src/core/: lv_indev.c lv_obj_style_gen.c lv_obj_tree.c lv_indev_scroll.c lv_obj_class.c lv_group.c lv_obj.c lv_obj_style.c lv_obj_pos.c lv_obj_draw.c lv_disp.c lv_event.c lv_theme.c lv_refr.c lv_obj_scroll.c
    packages/lvgl-8.3.11/src/extra/widgets/span/: lv_span.c
    packages/lvgl-8.3.11/src/widgets/: lv_canvas.c lv_checkbox.c lv_dropdown.c lv_roller.c lv_switch.c lv_table.c lv_bar.c lv_btn.c lv_label.c lv_slider.c lv_arc.c lv_textarea.c lv_line.c lv_objx_templ.c lv_img.c lv_btnmatrix.c
    packages/lvgl-8.3.11/src/draw/nxp/vglite/: lv_draw_vglite_arc.c lv_draw_vglite_rect.c lv_vglite_buf.c lv_vglite_utils.c lv_draw_vglite_line.c lv_draw_vglite.c lv_draw_vglite_blend.c
    packages/lvgl-8.3.11/examples/layouts/flex/: lv_example_flex_3.c lv_example_flex_4.c lv_example_flex_5.c lv_example_flex_6.c lv_example_flex_1.c lv_example_flex_2.c
    packages/lvgl-8.3.11/demos/stress/: lv_demo_stress.c
    packages/lvgl-8.3.11/examples/widgets/roller/: lv_example_roller_1.c lv_example_roller_3.c lv_example_roller_2.c
    packages/lvgl-8.3.11/src/draw/nxp/pxp/: lv_draw_pxp.c lv_gpu_nxp_pxp_osa.c lv_gpu_nxp_pxp.c lv_draw_pxp_blend.c
    packages/lvgl-8.3.11/demos/music/: lv_demo_music.c lv_demo_music_list.c lv_demo_music_main.c
    packages/lvgl-8.3.11/examples/widgets/label/: lv_example_label_3.c lv_example_label_5.c lv_example_label_2.c lv_example_label_4.c lv_example_label_1.c
    packages/lvgl-8.3.11/src/draw/sdl/: lv_draw_sdl_rect.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_img.c lv_draw_sdl_composite.c lv_draw_sdl_polygon.c lv_draw_sdl_utils.c lv_draw_sdl.c lv_draw_sdl_stack_blur.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_label.c lv_draw_sdl_mask.c lv_draw_sdl_texture_cache.c
    packages/lvgl-8.3.11/demos/widgets/: lv_demo_widgets.c
    packages/lvgl-8.3.11/examples/widgets/chart/: lv_example_chart_1.c lv_example_chart_4.c lv_example_chart_6.c lv_example_chart_2.c lv_example_chart_3.c lv_example_chart_5.c lv_example_chart_9.c lv_example_chart_7.c lv_example_chart_8.c
    packages/lvgl-8.3.11/examples/widgets/table/: lv_example_table_1.c lv_example_table_2.c
    packages/lvgl-8.3.11/src/extra/others/snapshot/: lv_snapshot.c
    packages/lvgl-8.3.11/examples/layouts/grid/: lv_example_grid_1.c lv_example_grid_2.c lv_example_grid_3.c lv_example_grid_4.c lv_example_grid_6.c lv_example_grid_5.c
    packages/lvgl-8.3.11/src/extra/widgets/msgbox/: lv_msgbox.c
    packages/lvgl-8.3.11/examples/scroll/: lv_example_scroll_5.c lv_example_scroll_1.c lv_example_scroll_2.c lv_example_scroll_4.c lv_example_scroll_6.c lv_example_scroll_3.c
    packages/lvgl-8.3.11/demos/benchmark/assets/: img_benchmark_cogwheel_indexed16.c lv_font_bechmark_montserrat_28_compr_az.c.c img_benchmark_cogwheel_alpha16.c img_benchmark_cogwheel_rgb565a8.c img_benchmark_cogwheel_argb.c img_benchmark_cogwheel_rgb.c lv_font_bechmark_montserrat_16_compr_az.c.c lv_font_bechmark_montserrat_12_compr_az.c.c img_benchmark_cogwheel_chroma_keyed.c
    packages/lvgl-8.3.11/examples/widgets/list/: lv_example_list_2.c lv_example_list_1.c
    packages/lvgl-8.3.11/src/extra/widgets/calendar/: lv_calendar_header_dropdown.c lv_calendar_header_arrow.c lv_calendar.c
    packages/lvgl-8.3.11/examples/get_started/: lv_example_get_started_2.c lv_example_get_started_3.c lv_example_get_started_1.c
    packages/lvgl-8.3.11/examples/widgets/bar/: lv_example_bar_4.c lv_example_bar_6.c lv_example_bar_1.c lv_example_bar_5.c lv_example_bar_3.c lv_example_bar_2.c
    packages/lvgl-8.3.11/src/extra/libs/qrcode/: qrcodegen.c lv_qrcode.c
    packages/lvgl-8.3.11/src/extra/widgets/colorwheel/: lv_colorwheel.c
    packages/lvgl-8.3.11/src/extra/libs/freetype/: lv_freetype.c
    packages/lvgl-8.3.11/examples/porting/: lv_port_disp_template.c lv_port_fs_template.c lv_port_indev_template.c
    packages/lvgl-8.3.11/examples/widgets/menu/: lv_example_menu_3.c lv_example_menu_5.c lv_example_menu_4.c lv_example_menu_1.c lv_example_menu_2.c
    packages/lvgl-8.3.11/src/extra/others/fragment/: lv_fragment_manager.c lv_fragment.c
    packages/lvgl-8.3.11/examples/assets/: imgbtn_right.c img_skew_strip.c img_caret_down.c img_hand.c img_cogwheel_indexed16.c img_cogwheel_alpha16.c img_cogwheel_argb.c img_cogwheel_rgb.c animimg001.c img_cogwheel_chroma_keyed.c animimg002.c animimg003.c img_star.c imgbtn_left.c imgbtn_mid.c
    packages/lvgl-8.3.11/examples/libs/rlottie/: lv_example_rlottie_1.c lv_example_rlottie_2.c lv_example_rlottie_approve.c
    packages/lvgl-8.3.11/examples/widgets/tabview/: lv_example_tabview_1.c lv_example_tabview_2.c
    packages/lvgl-8.3.11/src/extra/libs/png/: lodepng.c lv_png.c
    packages/lvgl-8.3.11/src/extra/libs/rlottie/: lv_rlottie.c
    packages/lvgl-8.3.11/src/extra/themes/default/: lv_theme_default.c
    packages/lvgl-8.3.11/examples/widgets/tileview/: lv_example_tileview_1.c
    packages/lvgl-8.3.11/src/extra/libs/tiny_ttf/: lv_tiny_ttf.c
    packages/lvgl-8.3.11/src/extra/widgets/menu/: lv_menu.c
    packages/lvgl-8.3.11/examples/widgets/img/: lv_example_img_1.c lv_example_img_4.c lv_example_img_2.c lv_example_img_3.c
    packages/lvgl-8.3.11/src/extra/libs/fsdrv/: lv_fs_stdio.c lv_fs_littlefs.c lv_fs_fatfs.c lv_fs_win32.c lv_fs_posix.c
    packages/lvgl-8.3.11/src/extra/widgets/led/: lv_led.c
    packages/lvgl-8.3.11/examples/others/msg/: lv_example_msg_3.c lv_example_msg_1.c lv_example_msg_2.c
    packages/lvgl-8.3.11/examples/widgets/slider/: lv_example_slider_1.c lv_example_slider_3.c lv_example_slider_2.c
    packages/lvgl-8.3.11/examples/widgets/animimg/: lv_example_animimg_1.c
    packages/lvgl-8.3.11/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    packages/lvgl-8.3.11/examples/others/fragment/: lv_example_fragment_1.c lv_example_fragment_2.c
    packages/lvgl-8.3.11/examples/widgets/meter/: lv_example_meter_3.c lv_example_meter_4.c lv_example_meter_1.c lv_example_meter_2.c
    packages/lvgl-8.3.11/src/extra/themes/basic/: lv_theme_basic.c
    packages/lvgl-8.3.11/examples/others/gridnav/: lv_example_gridnav_1.c lv_example_gridnav_4.c lv_example_gridnav_2.c lv_example_gridnav_3.c
    packages/lvgl-8.3.11/examples/widgets/keyboard/: lv_example_keyboard_1.c
    packages/lvgl-8.3.11/src/extra/layouts/flex/: lv_flex.c
    packages/lvgl-8.3.11/src/extra/widgets/tileview/: lv_tileview.c
    packages/lvgl-8.3.11/examples/libs/bmp/: lv_example_bmp_1.c
    packages/lvgl-8.3.11/examples/others/ime/: lv_example_ime_pinyin_2.c lv_example_ime_pinyin_1.c
    packages/lvgl-8.3.11/examples/widgets/arc/: lv_example_arc_2.c lv_example_arc_1.c
    packages/lvgl-8.3.11/examples/widgets/msgbox/: lv_example_msgbox_1.c
    packages/lvgl-8.3.11/src/extra/libs/gif/: lv_gif.c gifdec.c
    packages/lvgl-8.3.11/src/extra/widgets/spinbox/: lv_spinbox.c
    packages/lvgl-8.3.11/src/extra/widgets/tabview/: lv_tabview.c
    packages/lvgl-8.3.11/examples/libs/ffmpeg/: lv_example_ffmpeg_2.c lv_example_ffmpeg_1.c
    packages/lvgl-8.3.11/src/hal/: lv_hal_indev.c lv_hal_disp.c lv_hal_tick.c
    packages/lvgl-8.3.11/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    packages/lvgl-8.3.11/examples/widgets/dropdown/: lv_example_dropdown_1.c lv_example_dropdown_2.c lv_example_dropdown_3.c
    packages/lvgl-8.3.11/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    packages/lvgl-8.3.11/src/extra/widgets/imgbtn/: lv_imgbtn.c
    packages/lvgl-8.3.11/examples/others/monkey/: lv_example_monkey_1.c lv_example_monkey_2.c lv_example_monkey_3.c
    packages/lvgl-8.3.11/demos/widgets/assets/: img_clothes.c img_demo_widgets_avatar.c img_lvgl_logo.c
    packages/lvgl-8.3.11/examples/libs/sjpg/: lv_example_sjpg_1.c
    packages/lvgl-8.3.11/src/extra/libs/sjpg/: tjpgd.c lv_sjpg.c
    packages/lvgl-8.3.11/src/extra/widgets/keyboard/: lv_keyboard.c
    packages/lvgl-8.3.11/demos/keypad_encoder/: lv_demo_keypad_encoder.c
    packages/lvgl-8.3.11/examples/widgets/btn/: lv_example_btn_1.c lv_example_btn_3.c lv_example_btn_2.c
    packages/lvgl-8.3.11/src/extra/others/gridnav/: lv_gridnav.c
    packages/lvgl-8.3.11/examples/widgets/canvas/: lv_example_canvas_2.c lv_example_canvas_1.c
    packages/lvgl-8.3.11/src/extra/widgets/list/: lv_list.c
    packages/lvgl-8.3.11/examples/widgets/win/: lv_example_win_1.c
    packages/lvgl-8.3.11/src/extra/widgets/win/: lv_win.c
    packages/lvgl-8.3.11/examples/libs/qrcode/: lv_example_qrcode_1.c
    packages/lvgl-8.3.11/examples/widgets/imgbtn/: lv_example_imgbtn_1.c
    packages/lvgl-8.3.11/src/extra/others/msg/: lv_msg.c
    packages/lvgl-8.3.11/examples/anim/: lv_example_anim_1.c lv_example_anim_2.c lv_example_anim_3.c lv_example_anim_timeline_1.c
    packages/lvgl-8.3.11/src/draw/arm2d/: lv_gpu_arm2d.c
    packages/lvgl-8.3.11/examples/others/snapshot/: lv_example_snapshot_1.c
    packages/lvgl-8.3.11/examples/widgets/btnmatrix/: lv_example_btnmatrix_3.c lv_example_btnmatrix_1.c lv_example_btnmatrix_2.c
    packages/lvgl-8.3.11/examples/others/imgfont/: lv_example_imgfont_1.c
    packages/lvgl-8.3.11/examples/widgets/led/: lv_example_led_1.c
    packages/lvgl-8.3.11/src/extra/: lv_extra.c
    packages/lvgl-8.3.11/src/extra/widgets/meter/: lv_meter.c
    packages/lvgl-8.3.11/src/extra/libs/bmp/: lv_bmp.c
    packages/lvgl-8.3.11/examples/widgets/colorwheel/: lv_example_colorwheel_1.c
    packages/lvgl-8.3.11/examples/libs/freetype/: lv_example_freetype_1.c
    packages/lvgl-8.3.11/src/extra/widgets/animimg/: lv_animimg.c
    packages/lvgl-8.3.11/examples/libs/png/: img_wink_png.c lv_example_png_1.c
    packages/lvgl-8.3.11/examples/widgets/spinbox/: lv_example_spinbox_1.c
    packages/lvgl-8.3.11/src/extra/others/ime/: lv_ime_pinyin.c
    packages/lvgl-8.3.11/src/extra/widgets/chart/: lv_chart.c
    packages/lvgl-8.3.11/demos/benchmark/: lv_demo_benchmark.c
    packages/lvgl-8.3.11/examples/widgets/spinner/: lv_example_spinner_1.c
    packages/lvgl-8.3.11/examples/libs/gif/: img_bulb_gif.c lv_example_gif_1.c
    packages/lvgl-8.3.11/examples/widgets/switch/: lv_example_switch_1.c
    packages/lvgl-8.3.11/examples/widgets/line/: lv_example_line_1.c
    packages/lvgl-8.3.11/src/extra/widgets/spinner/: lv_spinner.c
    packages/lvgl-8.3.11/src/extra/layouts/grid/: lv_grid.c
    packages/lvgl-8.3.11/src/extra/others/imgfont/: lv_imgfont.c
    packages/lvgl-8.3.11/src/extra/others/monkey/: lv_monkey.c
  group LVGL-port
    applications/lvgl_porting/: lv_lcd_dev.c lv_port_disp.c
    packages/lvgl-8.3.11/env_support/rt-thread/: lv_rt_thread_port.c
  group offline_download
    applications/flmparse/: flmparse.c
    applications/offline_download/: swd_download_file.c
  group Utilities
    rt-thread/components/utilities/ulog/: ulog.c
    rt-thread/components/utilities/ulog/backend/: console_be.c
